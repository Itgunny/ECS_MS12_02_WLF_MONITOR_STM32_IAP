# IAR project WL9F_Monitor_IAP.ewp, settings and files
configuration STM324xG (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX; USE_STM324xG_EVAL; USE_FULL_ASSERT
  ICCARM.CCIncludePath2: ..\Platform\INC; ..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\Utilities\STM32_EVAL\Common; ..\Utilities\STM32_EVAL\STM3240_41_G_EVAL
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: WL9F_Monitor_IAP.hex
  ILINK.IlinkOutputFile: WL9F_Monitor_IAP.out
  ILINK.IlinkIcfFile: LinkerConfiguration\stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group EWARM
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f4xx.s
  group IAP/INC
    ../Platform/INC/: common.h flash_if.h FM31X4.h GPIO_Control.h LCD_Control.h M25PXX.h menu.h stm324xg_eval.h stm32_eval_legacy.h stm32f4xx_conf.h stm32f4xx_it.h System_Init.h TimeDelay.h TW8816_Control.h TW8816_OSD.h WL9F_Monitor_IAP.h ymodem.h
  group IAP/SRC
    ../Platform/SRC/: common.c flash_if.c FM31X4.c GPIO_Control.c LCD_Control.c M25PXX.c main.c menu.c stm324xg_eval.c stm32f4xx_it.c System_Init.c system_stm32f4xx.c TimeDelay.c TW8816_Control.c TW8816_OSD.c ymodem.c
  group STM32F4xx_StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
